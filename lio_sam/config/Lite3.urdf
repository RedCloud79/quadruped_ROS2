Commit message: update

File: lio_sam/config/Lite3.urdf (robot description, URDF)
Before this commit: robot Lite3, 19 links, 18 joints
Joints:
- joint base_to_livox: origin xyz=0.16 0 0.13 rpy=0 0.35 0 -> xyz=0 0 0 rpy=0 0 0
